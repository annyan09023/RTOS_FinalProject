# Keil uVision project lab2.uvproj, settings and files
target lab2 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADCT0ATrigger.c PLL.c Timer1A.c UART2.c startup.s ADCT0ATrigger.h FIFO.h PLL.h Timer1A.h UART2.h osasm.s os.h cr4_fft_64_stm32.s PID_stm32.s tm4c123gh6pm.h ST7735.h ST7735.c lab2.c os.c ADCSWTrigger.c
